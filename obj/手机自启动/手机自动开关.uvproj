# Keil uVision project 手机自动开关.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: 手机自动开关 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC8G.h
